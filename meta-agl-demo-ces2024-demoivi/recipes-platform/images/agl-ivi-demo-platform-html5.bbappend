IMAGE_INSTALL += " \
    packagegroup-agl-demo-music-data \
    psplash \
    tzdata \
"

IMAGE_LINGUAS = "en-us ja-jp"
