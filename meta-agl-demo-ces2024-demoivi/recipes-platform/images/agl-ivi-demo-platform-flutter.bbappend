IMAGE_INSTALL += " \
    packagegroup-agl-demo-music-data \
    tzdata \
"

IMAGE_LINGUAS = "en-us ja-jp"
