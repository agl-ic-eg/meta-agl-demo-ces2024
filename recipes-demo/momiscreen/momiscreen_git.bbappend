SRC_URI = "git://github.com/AGLExport/momiscreen;protocol=https;branch=main \
           file://momiscreen.service \
           file://momiscreen \
          "
SRCREV = "819d56db4295b81ad24881dd1952cd5b0783a63a"
