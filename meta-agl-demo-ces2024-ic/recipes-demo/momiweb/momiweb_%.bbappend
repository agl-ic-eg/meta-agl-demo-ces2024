FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRCREV = "0443d1c49b6982092890fd980d649a1ad46cfc8b"

RDEPENDS:${PN} += "\
    momicalc \
    "
