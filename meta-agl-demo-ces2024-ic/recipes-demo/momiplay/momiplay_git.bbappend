FILESEXTRAPATHS:prepend := "${THISDIR}/momiplay:"

SRC_URI:append = " \
    file://0001-Rework-momiplayer-info-panel.patch \
    "
