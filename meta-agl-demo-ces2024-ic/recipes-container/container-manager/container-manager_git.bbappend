SRC_URI = " \
    git://github.com/AGLExport/container-manager.git;branch=dev-target3;protocol=https \
    file://container-manager.service \
    file://container-manager.json \
    "
SRCREV = "1958b8d5c490f9d9990c363e389fc733a6e94e64"
