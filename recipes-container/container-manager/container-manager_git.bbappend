SRC_URI = " \
    git://github.com/AGLExport/container-manager.git;branch=dev-target3;protocol=https \
    file://container-manager.service \
    file://container-manager.json \
    "
SRCREV = "7d89e3a0cf529a43cf6a76a394860e364457781e"
